Commit message: reward function changed

File: data/spheregoal.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 1 links, 0 joints
Links:
- link base_link: geometry visual sphere radius=0.03
